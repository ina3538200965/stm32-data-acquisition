# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\Library;.\User;.\driver;.\app;.\protocol;.\test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h startup_stm32f10x_md.s
  group Library
    ./Library/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ./User/: main.c stm32f10x_conf.h
  group driver
    ./driver/: driver_led.c driver_led.h driver_adc.h driver_adc.c driver_usart.c driver_usart.h ringbuf.c ringbuf.h driver_i2c.c driver_i2c.h driver_mpu6500.c driver_mpu6500.h driver_ssd1306.c driver_ssd1306.h driver_spi.c driver_spi.h driver_w25q64.c driver_w25q64.h font6x8.h
  group app
    ./app/: app.c app.h stm32f10x_it.c stm32f10x_it.h
  group protocol
    ./protocol/: protocol.c protocol.h
  group test
    ./test/: test_protocol.c test_protocol.h test_ringbuf.c test_ringbuf.h test_pipeline.c test_pipeline.h
